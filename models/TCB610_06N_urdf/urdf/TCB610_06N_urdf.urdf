Commit message: 2026.10.14

File: models/TCB610_06N_urdf/urdf/TCB610_06N_urdf.urdf (robot description, URDF)
Before this commit: robot TCB610_06N_urdf, 8 links, 7 joints
Links:
- link tl_robot_link_end: geometry collision box size=0.001 0.001 0.001; visual box size=.01 .01 .01
